options:
  parameters:
    author: Maxim
    category: Custom
    description: |-
      ZMQ Channel Broker for srsRAN 5G NR — sits between gNB and UE,
      applies AWGN + Rician/Rayleigh fading to IQ samples while preserving ZMQ
      REQ/REP message boundaries (23040 samples/subframe at 23.04 MHz).
    generate_options: qt_gui
    id: srsran_channel_broker
    output_language: python
    title: srsRAN 5G NR Channel Broker
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: snr_db
  id: variable
  parameters:
    value: '28.0'
  states: {}
- name: k_factor_db
  id: variable
  parameters:
    value: '3.0'
  states: {}
- name: doppler_hz
  id: variable
  parameters:
    value: '5.0'
  states: {}
- name: fading_en
  id: variable
  parameters:
    value: '1'
  states: {}
- name: gnb_tx_port
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: gnb_rx_port
  id: variable
  parameters:
    value: '4001'
  states: {}
- name: ue_rx_port
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: ue_tx_port
  id: variable
  parameters:
    value: '2001'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 1.0 / math.sqrt(2.0 * pow(10, snr_db / 10.0))
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_threading
  id: import
  parameters:
    imports: import threading
  states: {}
- name: import_zmq
  id: import
  parameters:
    imports: import zmq as _zmq
  states: {}
- name: import_scipy
  id: import
  parameters:
    imports: from scipy.special import j0 as bessel_j0
  states: {}
- name: import_collections
  id: import
  parameters:
    imports: import collections
  states: {}
- name: snr_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: SNR (dB)
    start: '5'
    step: '0.5'
    stop: '40'
    value: snr_db
  states: {}
- name: k_factor_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: K-Factor (dB)
    start: '-10'
    step: '0.5'
    stop: '20'
    value: k_factor_db
  states: {}
- name: doppler_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Doppler (Hz)
    start: '0.1'
    step: '1'
    stop: '300'
    value: doppler_hz
  states: {}
- name: fading_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,2
    label: Fading
    label0: Off (AWGN only)
    label1: Rician
    label2: Rayleigh
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: fading_en
    widget: radio_buttons
  states: {}
- name: epy_block_broker
  id: epy_block
  parameters:
    _source_code: '"""\nEmbedded Python Block: srsRAN ZMQ Channel Broker\n\nRuns two relay threads (DL / UL) that proxy ZMQ REQ/REP\nmessages between gNB and UE, applying AWGN + flat Rician/Rayleigh\nfading.  Outputs the most recent DL IQ to a GNU Radio\nstreaming port so QT GUI sinks can visualise the channel.\n\nPort topology (same as C zmq_channel_broker):\n  gNB TX (REP :4000) -> Broker DL -> :2000 UE RX\n  UE  TX (REP :2001) -> Broker UL -> :4001 gNB RX\n"""\n\nimport numpy as np\nimport math, threading, collections\n\nfrom gnuradio import gr\nimport zmq as _zmq\nfrom scipy.special import j0 as bessel_j0\n\n\nclass FadingState:\n\    def __init__(self, enabled, doppler, samp_rate, k_db, rng):\n        self.enabled = enabled\n        self.doppler = doppler\n        self.samp_rate = samp_rate\n   \     self.rng = rng\n        k_lin = 10.0 ** (k_db / 10.0)\n        kp1 = k_lin + 1.0\n        self.los_amp = math.sqrt(k_lin / kp1)\n        self.scatter_amp = math.sqrt(1.0 / kp1)\n        if enabled:\n     \       self.h_I = rng.standard_normal() * math.sqrt(0.5)\n\            self.h_Q = rng.standard_normal() * math.sqrt(0.5)\n\        else:\n            self.h_I = 1.0\n         \   self.h_Q = 0.0\n\n    def update_and_apply(self, iq):\n        if not self.enabled:\n            return iq\n        n = len(iq)\n        T = n / self.samp_rate\n\        alpha = float(bessel_j0(2.0 * math.pi * self.doppler * T))\n        sigma = math.sqrt(max(0.0, (1.0 - alpha * alpha) * 0.5))\n        n1, n2 = self.rng.standard_normal(2)\n\        self.h_I = alpha * self.h_I + sigma * n1\n\        self.h_Q = alpha * self.h_Q + sigma * n2\n\        h = complex(self.los_amp + self.scatter_amp * self.h_I,\n                    self.scatter_amp * self.h_Q)\n        return iq * np.complex64(h)\n\n\    def reconfigure(self, enabled, doppler, k_db):\n\        self.enabled = enabled\n        self.doppler = doppler\n        k_lin = 10.0 ** (k_db / 10.0)\n\        kp1 = k_lin + 1.0\n        self.los_amp = math.sqrt(k_lin / kp1)\n        self.scatter_amp = math.sqrt(1.0 / kp1)\n\n\ndef add_awgn(iq, noise_std, rng):\n  \  noise = (rng.standard_normal(len(iq))\n           \  + 1j * rng.standard_normal(len(iq))) * np.float32(noise_std)\n\    return iq + noise.astype(np.complex64)\n\n\ndef relay_thread(label, src_addr, dst_addr, noise_std_ref, fading, rng, stop_ev, viz_buf):\n    ctx = _zmq.Context()\n\    tmo = 500\n    req = ctx.socket(_zmq.REQ)\n  \  req.setsockopt(_zmq.LINGER, 0)\n    req.setsockopt(_zmq.RCVTIMEO, tmo)\n    req.setsockopt(_zmq.SNDTIMEO, tmo)\n    req.connect(src_addr)\n    rep = ctx.socket(_zmq.REP)\n\    rep.setsockopt(_zmq.LINGER, 0)\n    rep.setsockopt(_zmq.RCVTIMEO, tmo)\n    rep.setsockopt(_zmq.SNDTIMEO, tmo)\n    rep.bind(dst_addr)\n    count = 0\n    while not stop_ev.is_set():\n\        try:\n            try:\n                downstream_req = rep.recv()\n            except _zmq.Again:\n    \            continue\n            req.send(downstream_req)\n\            while not stop_ev.is_set():\n            \    try:\n                    raw = req.recv()\n   \                 break\n                except _zmq.Again:\n\                    continue\n            if stop_ev.is_set():\n\                break\n            iq = np.frombuffer(raw, dtype=np.complex64).copy()\n            iq = fading.update_and_apply(iq)\n\            iq = add_awgn(iq, noise_std_ref[0], rng)\n\            rep.send(iq.tobytes())\n            count += 1\n            if label == ''DL'' and viz_buf is not None:\n                viz_buf.append(iq)\n        \    if count == 1:\n                print(f''[GRC] {label}: first msg relayed ({len(iq)} samples)'')\n        except _zmq.ZMQError as e:\n            if stop_ev.is_set():\n\                break\n            print(f''[GRC] {label}: ZMQ error: {e}'')\n            break\n    req.close()\n\    rep.close()\n    ctx.term()\n    print(f''[GRC] {label}: exiting (relayed {count} msgs)'')\n\n\nclass channel_broker_source(gr.sync_block):\n    \"\"\"ZMQ Channel Broker — relays IQ with impairments and\n  \  outputs DL stream for visualisation.\"\"\"\n\n\    def __init__(self, snr_db=28.0, k_factor_db=3.0, doppler_hz=5.0,\n                 fading_en=1, samp_rate=23.04e6,\n\                 gnb_tx_port=4000, gnb_rx_port=4001,\n\                 ue_rx_port=2000, ue_tx_port=2001):\n\        gr.sync_block.__init__(self,\n            name=''srsRAN ZMQ Channel Broker'',\n            in_sig=[],\n    \        out_sig=[np.complex64])\n        self.samp_rate = samp_rate\n        self.snr_db = snr_db\n        self.k_factor_db = k_factor_db\n        self.doppler_hz = doppler_hz\n        self.fading_en = fading_en\n\        self.gnb_tx_port = gnb_tx_port\n        self.gnb_rx_port = gnb_rx_port\n        self.ue_rx_port = ue_rx_port\n\        self.ue_tx_port = ue_tx_port\n        self._dl_noise_std = [1.0 / math.sqrt(2.0 * pow(10, snr_db / 10.0))]\n\        self._ul_noise_std = [1.0 / math.sqrt(2.0 * pow(10, snr_db / 10.0))]\n        self._stop = threading.Event()\n\        self._viz_buf = collections.deque(maxlen=4)\n\        self._dl_rng = np.random.default_rng(42)\n\        self._ul_rng = np.random.default_rng(137)\n\        fading_on = fading_en >= 1\n        k_db = 0.0 if fading_en == 2 else k_factor_db\n        self._dl_fading = FadingState(fading_on, doppler_hz, samp_rate, k_db, self._dl_rng)\n        self._ul_fading = FadingState(fading_on, doppler_hz, samp_rate, k_db, self._ul_rng)\n\n    def start(self):\n        self._stop.clear()\n     \   addr = ''127.0.0.1''\n        self._dl_thread = threading.Thread(\n\            target=relay_thread,\n            args=(''DL'',\n\                  f''tcp://{addr}:{self.gnb_tx_port}'',\n\                  f''tcp://0.0.0.0:{self.ue_rx_port}'',\n\                  self._dl_noise_std, self._dl_fading,\n\                  self._dl_rng, self._stop, self._viz_buf),\n\            daemon=True)\n        self._ul_thread = threading.Thread(\n            target=relay_thread,\n\            args=(''UL'',\n                  f''tcp://{addr}:{self.ue_tx_port}'',\n\                  f''tcp://0.0.0.0:{self.gnb_rx_port}'',\n\                  self._ul_noise_std, self._ul_fading,\n\                  self._ul_rng, self._stop, None),\n\            daemon=True)\n        self._dl_thread.start()\n\        self._ul_thread.start()\n        print(''[GRC] Relay threads started'')\n        return True\n\n\    def stop(self):\n        self._stop.set()\n   \     print(''[GRC] Stopping relay threads...'')\n     \   return True\n\n    def work(self, input_items, output_items):\n\        out = output_items[0]\n        n = len(out)\n\        if self._viz_buf:\n            iq = self._viz_buf[-1]\n\            avail = len(iq)\n            use = min(n, avail)\n            out[:use] = iq[:use]\n         \   if use < n:\n                out[use:] = np.zeros(n - use, dtype=np.complex64)\n        else:\n         \   out[:] = np.zeros(n, dtype=np.complex64)\n        return n\n\n    def set_snr_db(self, val):\n      \  self.snr_db = val\n        ns = 1.0 / math.sqrt(2.0 * pow(10, val / 10.0))\n        self._dl_noise_std[0] = ns\n        self._ul_noise_std[0] = ns\n\n    def set_k_factor_db(self, val):\n        self.k_factor_db = val\n        k = 0.0 if self.fading_en == 2 else val\n        self._dl_fading.reconfigure(self.fading_en >= 1, self.doppler_hz, k)\n        self._ul_fading.reconfigure(self.fading_en >= 1, self.doppler_hz, k)\n\n    def set_doppler_hz(self, val):\n        self.doppler_hz = val\n        k = 0.0 if self.fading_en == 2 else self.k_factor_db\n\        self._dl_fading.reconfigure(self.fading_en >= 1, val, k)\n        self._ul_fading.reconfigure(self.fading_en >= 1, val, k)\n\n    def set_fading_en(self, val):\n\        self.fading_en = val\n        k = 0.0 if val == 2 else self.k_factor_db\n        self._dl_fading.reconfigure(val >= 1, self.doppler_hz, k)\n        self._ul_fading.reconfigure(val >= 1, self.doppler_hz, k)\n'
    comment: |-
      ZMQ relay threads preserve message boundaries (23040 samples/subframe).
      DL processed IQ is output to the streaming port for visualisation.
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,2,2
    label1: DL IQ Spectrum
    name: '"DL Channel Spectrum"'
    type: complex
    width1: '2'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,2,2,2
    label1: I
    label2: Q
    name: '"DL IQ Waveform"'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,0,2,2
    label1: DL IQ
    name: '"DL Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 4,2,2,2
    int_min: '-80'
    name: '"DL Waterfall"'
    type: complex
  states: {}
- name: note_callbacks
  id: note
  parameters:
    comment: |-
      Parameter changes are forwarded to the broker block via callbacks:
      snr_db -> set_snr_db(), k_factor_db -> set_k_factor_db(),
      doppler_hz -> set_doppler_hz(), fading_en -> set_fading_en()
  states: {}

connections:
- [epy_block_broker, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
